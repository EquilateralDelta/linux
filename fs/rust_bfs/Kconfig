## fs/rust_bfs/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only
config RUST_BFS_FS
	tristate "Rust BFS file system support"
	depends on BLOCK
	select BUFFER_HEAD
```
